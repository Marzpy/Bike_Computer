# Repository Marzpy/Bike_Computer

## KiCad design bike/bike.kicad_pcb

Parts:
BT1: Battery; TerminalBlock_Altech_AK300-2_P5.00mm
C1: 1000u; CP_Elec_10x10
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
HG1: HallGenerator; TO-92Flat
LS1: Speaker; TerminalBlock_Altech_AK300-2_P5.00mm
Q1: BCP56; SOT-223-3_TabPin2
R1: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4, R5: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_PUSH_6mm_H8mm
SW2, SW3: SW_PUSH_6mm_H5mm
U2: RC1602A
U3: BP; blue_pill

Connections:
+5V: BT1.1 (+), C1.1, D1.2 (A), Q1.2 (C), R2.1, R3.1, R4.1, R6.1, U2.2 (VDD), U2.15 (A/VEE), U3.5V
AUDIO_PWM: R1.1, U3.PA1
BTN_1: R4.2, SW3.2 (B), U3.PB1
BTN_2: R3.2, SW2.2 (B), U3.PB4
BTN_3: R2.2, SW1.2 (B), U3.PB3
GND: BT1.2 (-), C1.2, HG1.2 (U2), LS1.1, R5.2, SW1.1 (A), SW2.1 (A), SW3.1 (A), U2.1 (VSS), U2.5 (R/W), U2.16 (K), U3.G (GND)
HAL_SG: HG1.3 (UH1), U3.PA2
LCD_DB4: U2.11 (DB4), U3.PB0
LCD_DB5: U2.12 (DB5), U3.PA7
LCD_DB7: U2.14 (DB7), U3.PA5
LCD_DN6: U2.13 (DB6), U3.PA6
LCD_E: U2.6 (E), U3.PB10
LCD_RS: U2.4 (RS), U3.PB11
unnamed: D1.1 (K), R5.1
unnamed: HG1.1 (U1), R6.2
unnamed: Q1.1 (B), R1.2
unnamed: LS1.2, Q1.3 (E)

Notes on the sheet:
POWER AMP
POWER SUPPLY
BUTTONS
LCD SCREEN
STM32 MODULE
SPEED METER

Board: 2 copper layers, 91.4 x 91.9 mm, 17 parts (0 on the bottom side), 17 nets.

## KiCad design stm_bluepill_footprint/blue_pill2/df-pill-release/device/df-pill/df-pill.kicad_pcb

File stm_bluepill_footprint/blue_pill2/df-pill-release/README.md:

# df-pill

This project was extracted from another, complex device project which originally
targeted cheap STM32F103C8T6 board known as "bluepill" as main board.
However, it soon became apparent that bluepill has shortcomings with USB
interface, which was meant to be primary communication channel.

**tl;dr** bluepill cannot work with USB while being externally powered.
It is designed to be powered with USB host only.
Some bluepill boards have hardware bugs.

To overcome problems this board was designed.
It has a number of enhancements and was thought to be maximally generic.

**Enhancements:**

1. Improved USB
  > USB now has optional ESD protection, implements VBUS sense with software
  > and is fully detachable via jumpers.

2. Every pin has external connection
  > NOTE: some pins like PC14, PC15, BOOT0 don't have terminals at the board
  > sides, but still have them at crystal mount points and boot pin headers.

3. Separate analog terminals VDDA and GNDA and separate analog ground
  > NOTE: It is required to provide VDDA and GNDA or simply join them
  > with VDD and GNDD. GNDA and GNDD may be joined on board with jumper.
  > VDD and VDDA may be joined via terminals.

4. Detachable add-ons
  > On-board LEDs and keys can be detached with jumpers.

5. VDD and +5V inputs are protected power inputs.
  > All power supply nets are now protected with Schottky diodes.

The goal of this project is to learn electronics while creating a useful device,
for everyone. So keep in mind that this device isn't designed by professional.

It is assumed that user is able to perform all necessary tasks related to
device creation, which are not covered with project files. User must also
perform all necessary precautions on every such task. See [LICENSE](LICENSE).

This means things like electrical safety, soldering, parts ordering and
PCB manufacturing are out of the scope. As a note, if you think you can
buy bluepill, disassemble it and apply its parts to this board, then
you're right. Bluepill has core parts, but some other uncommon ones need
to be ordered.

# How to use

Install Kicad EDA and open project file: `device/df-pill/df-pill.pro`.
Original project was made with *Kicad EDA 5.1.5-3*

You don't need any library installed, because project is fully autonomous.
It has all symbols, footprints and 3D models in `device/df-pill/lib` dir.

If you like to change anything it is recommended to first add new items
to library and then use them in project to maintain autonomous project
structure.

If you'd like to have multiple boards on a single copper plate
read `device/panelization.md`.

# Versioning

Schematic and and PCB have different, but related version formats.

- Schematic: **X.Y**
- PCB: **X.Y.Z**

Where **X** = major version, **Y** = minor version, **Z** = patch.

Schematic major version increment breaks external interface.
Minor version increment changes components, but external interface
is the same. Any schematic version change breaks PCB layout.

PCB's major and minor versions are from schematic versions.
Patches are PCB modifications/optimizations that are fully
compatible with current schematic.

# References

A number of resources was used in this project.
See [reference.md](reference.md) for list.

# License

This project is licensed under [The Unlicense](LICENSE).
It contains library files from KiCAD EDA library in `device/lib`.
These files are licensed under [KiCAD EDA Libraries License](https://kicad-pcb.org/libraries/license/)

Parts:
C1, C3, C4, C5, C11: 100nF; C_0603_1608Metric
C2: 10uF; C_0805_2012Metric
C6: 1uF; C_0805_2012Metric
C7: 10nF; C_0603_1608Metric
C8: 4.7uF; C_0805_2012Metric
C9: 470pF; C_0603_1608Metric
C10: 2.2uF; C_0805_2012Metric
C12, C13: 20pF; C_0603_1608Metric
C14, C16: 12pF; C_0603_1608Metric
D1, D3, D4, D7, D8: BAT60A; D_SOD-323
D2: ESDA7P60-1U1M; D_1610Metric
D5: LED_VDD; LED_0805_2012Metric
D6: LED_USER; LED_0805_2012Metric
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001
JP1: BAT_VDD; PinHeader_1x03_P2.54mm_Vertical
JP2: 0; R_1812_4532Metric
JP3: BOOT01; PinHeader_2x03_P2.54mm_Vertical
JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11: 0; R_0603_1608Metric
P1: Connector_A; PinHeader_1x20_P2.54mm_Vertical
P2: Connector_B; PinHeader_1x20_P2.54mm_Vertical
P3: Connector_SWD; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R4, R6, R8, R12: 10K; R_0603_1608Metric
R3: 390; R_0603_1608Metric
R5: 1.5K; R_0603_1608Metric
R7: 18K; R_0603_1608Metric
R9, R10: 1.1K; R_0603_1608Metric
R11, R13: 0; R_0603_1608Metric
SW1: RESET; SW_SPST_CK_RS282G05A3
SW2: KEY; SW_SPST_CK_RS282G05A3
U1: MIC5219-3.3YM5; SOT-23-5
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U3: USBLC6-2SC6; SOT-23-6
Y1: 8MHz; Crystal_HC49-4H_Vertical
Y2: 32.768KHz; Crystal_SMD_Abracon_ABS25-4Pin_8.0x3.8mm

Connections:
+5V: C2.1, C4.1, D7.1 (K), JP9.1, U1.1 (IN), U1.3 (EN)
/BOOT0: R2.2, U2.44 (BOOT0)
/PA0: JP5.2, P1.1 (PA0), U2.10 (PA0-WKUP)
/PA1: P1.2 (PA1), U2.11 (PA1)
/PA2: P1.3 (PA2), U2.12 (PA2)
/PA3: P1.4 (PA3), U2.13 (PA3)
/PA4: P1.5 (PA4), U2.14 (PA4)
/PA5: P1.6 (PA5), U2.15 (PA5)
/PA6: P1.7 (PA6), U2.16 (PA6)
/PA7: P1.8 (PA7), U2.17 (PA7)
/PA8: P1.18 (PA8), U2.29 (PA8)
/PA9: P1.19 (PA9), U2.30 (PA9)
/PA10: JP11.1, P2.20 (PA10), U2.31 (PA10)
/PA11: JP10.1, P2.19 (PA11), U2.32 (PA11)
/PA12: JP7.1, P2.18 (PA12), U2.33 (PA12)
/PA13: P2.17 (PA13), P3.2 (SWDIO), U2.34 (PA13)
/PA14: P2.16 (PA14), P3.3 (SWDCLK), U2.37 (PA14)
/PA15: P2.15 (PA15), U2.38 (PA15)
/PB0: P1.9 (PB0), U2.18 (PB0)
/PB1: P1.10 (PB1), U2.19 (PB1)
/PB2: P1.11 (PB2), R8.2, U2.20 (PB2-BOOT1)
/PB3: P2.14 (PB3), U2.39 (PB3)
/PB4: P2.13 (PB4), U2.40 (PB4)
/PB5: P2.12 (PB5), U2.41 (PB5)
/PB6: P2.11 (PB6), U2.42 (PB6)
/PB7: P2.10 (PB7), U2.43 (PB7)
/PB8: P2.9 (PB8), U2.45 (PB8)
/PB9: P2.8 (PB9), U2.46 (PB9)
/PB10: JP8.1, P1.12 (PB10), U2.21 (PB10)
/PB11: JP6.1, P1.13 (PB11), U2.22 (PB11)
/PB12: P1.14 (PB12), U2.25 (PB12)
/PB13: P1.15 (PB13), U2.26 (PB13)
/PB14: P1.16 (PB14), U2.27 (PB14)
/PB15: P1.17 (PB15), U2.28 (PB15)
/PC13: P2.4 (PC13), U2.2 (PC13-TAMPER-RTC)
/PC14: R13.2, U2.3 (PC14-OSC32_IN)
/PC15: R11.2, U2.4 (PC15-OSC32_OUT)
/PD0: C12.1, U2.5 (OSC_IN-PD0), Y1.1
/PD1: R3.2, U2.6 (OSC_OUT-PD1)
/RESET: C11.1, P2.3 (NRST), R1.2, SW1.1, U2.7 (NRST)
/VBAT: JP1.1 (A), P2.5 (VBAT)
GNDA: C6.2, C7.2, JP2.1, P2.2 (GNDA), U2.8 (VSSA)
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, D2.2 (A2), J1.5 (GND), J1.6 (Shield), JP2.2, JP3.3 (B), JP3.6 (B), P2.7 (GNDD), P3.4 (GNDD), R7.2, R9.1, R10.1, SW1.2, SW2.1, U1.2 (GND), U2.23 (VSS_1), U2.35 (VSS_2), U2.47 (VSS_3), U3.2 (GND)
unnamed: C9.1, U1.4 (BP)
unnamed: C10.1, D1.2 (A), U1.5 (OUT)
unnamed: C13.1, R3.1, Y1.2
unnamed: C14.1, R13.1, Y2.1
unnamed: C16.1, R11.1, Y2.4
unnamed: D2.1 (A1), D4.2 (A), J1.1 (VBUS), R6.2, U3.5 (VBUS)
unnamed: D3.2 (A), P3.1 (+3V3)
unnamed: D4.1 (K), JP9.2
unnamed: D5.1 (K), R9.2
unnamed: D5.2 (A), JP4.1
unnamed: D6.1 (K), R10.2
unnamed: D6.2 (A), JP5.1
unnamed: D7.2 (A), P1.20 (+5V)
unnamed: D8.2 (A), P2.6 (VDD)
unnamed: J1.2 (D-), JP10.2, U3.3 (IO2), U3.4 (IO2)
unnamed: J1.3 (D+), JP7.2, R5.2, U3.1 (IO1), U3.6 (IO1)
unnamed: JP1.2 (C), U2.1 (VBAT)
unnamed: JP3.2 (C), R2.1
unnamed: JP3.5 (C), R8.1
unnamed: JP6.2, R5.1
unnamed: JP8.2, R12.1
unnamed: JP11.2, R4.1, SW2.2
unnamed: R6.1, R7.1, R12.2
VDD: C1.1, C3.1, C5.1, C8.1, D1.1 (K), D3.1 (K), D8.1 (K), JP1.3 (B), JP3.1 (A), JP3.4 (A), JP4.2, R1.1, R4.2, U2.24 (VDD_1), U2.36 (VDD_2), U2.48 (VDD_3)
VDDA: C6.1, C7.1, P2.1 (VDDA), U2.9 (VDDA)

Notes on the sheet:
Power
GNDD and GNDA may be joined on board. VDD and VDDA may be joined via connector pins.
Oscillators
Boot Mode
HSE
LSE
DMX-26S
Reset
VDD, VDDA = +3.3V
MCU
USB
LEDs
tantallum
SWD
Main connectors
Key
V_PB10 = 3.214 V

Board: 2 copper layers, 30.0 x 68.5 mm, 58 parts (45 on the bottom side), 68 nets.

## Commit log

2024-12-09 Initial
